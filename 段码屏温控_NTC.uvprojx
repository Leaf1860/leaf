# Keil uVision project 段码屏温控_NTC.uvprojx, settings and files
target Lcd_NTC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F005C6PA HDSC
  pack: HDSC.HC32F005.1.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Lcd_NTC_2019_12_12_V10 +hex
  c flags: Optim=2 OneElfS=1 wLevel=1
  c include: ..\mcu\common;..\source;..\driver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f003.s
    ../mcu/common/: system_hc32f003.c
  group source
    ../source/: main.c TIM1.c ADC_Process.c TIM2.c Timer_Work.c NTC_table.c REALY_OUT.c HT1621.c DS1307.c Key.c
  group driver
    ../driver/src/: ddl.c clk.c gpio.c adc.c bt.c flash.c i2c.c interrupts_hc32f005.c HDEE5.c
software components: CMSIS:CORE 5.1.1
